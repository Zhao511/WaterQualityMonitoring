# Keil uVision project water_quality_monitor.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: water_quality_monitor
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Core\Inc;.\Drivers\Inc;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\FreeRTOS\inc;.\FreeRTOS-Kernel\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  memory RVCT1: ROM 0x8000000 size 0x10000
  memory RVCT2: ROM 0x20000000 size 0x5000
  scatter file: .\water_quality_monitor.sct
  group Core
    ./Core/Src/: main.c system_stm32f10x.c stm32f10x_it.c
  group Startup
    ./Core/Src/: startup_stm32f10x_md.s
  group Drivers
    ./Drivers/Src/: led_rgb.c lora.c gps.c rc522.c sensor_temp.c usart_debug.c sensor_tds.c sensor_ph.c adc_common.c watchdog.c
    ./: 
  group Libraries
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c
  group FreeRTOS
    ./FreeRTOS-Kernel/FreeRTOS-Kernel/: tasks.c queue.c list.c timers.c
    ./FreeRTOS-Kernel/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS-Kernel/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group IoT
    ./Core/Src/: iot_json.c iot_service.c iot_transport.c
